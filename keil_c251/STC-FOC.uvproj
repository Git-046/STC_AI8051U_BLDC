# Keil uVision project STC-FOC.uvproj, settings and files
target Target_1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: STC-FOC +hex
  group Library
    ../LIB/: ai_usb.h AI8051U.H AI8051U_32_MDU32.LIB AI8051U_32_TFPU.LIB config.h def.h Type_def.h ADC.c ADC.h Clock.c Clock.h Compare.c Compare.h Delay.c Delay.h DMA.c DMA.h EEPROM.c EEPROM.h Exti.c Exti.h GPIO.c GPIO.h I2C.h I2C.c LCM.c LCM.h NVIC.c NVIC.h PWM.c PWM.h RTC.c RTC.h Soft_I2C.c Soft_I2C.h Soft_UART.c Soft_UART.h SPI.c SPI.h Switch.h Timer.c Timer.h UART.c UART.h USART_LIN.c USART_LIN.h WDT.c WDT.h
  group Motor
    ../Motor/: Init.c Init.h main.c Motor.c Motor.h Foc.h Foc.c interrpt.c interrupt.h State_Machine.c State_Machine.h Protect.c
